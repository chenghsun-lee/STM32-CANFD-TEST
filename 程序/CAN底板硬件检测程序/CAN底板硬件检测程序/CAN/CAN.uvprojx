# Keil uVision project CAN.uvprojx, settings and files
target STM32F105 Flash (6190000::V6.19::ARMCLANG)
  device: STM32F105RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x801FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: CanDemo_15 +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=5
  c define: USE_STDPERIPH_DRIVER,STM32F10X_CL
  c include: ..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\CAN;.\User;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\CMSIS\CM3\CoreSupport
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group StartUp
    ./User/: stm32f10x_conf.h
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s
  group Source Files
    ./User/: CAN.c CanDemo.c
  group New Group
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_can.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
