# Keil uVision project CAN.uvprojx, settings and files
target STM32F103 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CanDemo_15 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\CAN;..\Libraries\CMSIS\CM3\CoreSupport;.\User;.\User\app;.\User\canfdspi;.\User\spi
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group StartUp
    ./User/: stm32f10x_conf.h
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s startup_stm32f10x_cl.s
  group Source Files
    ./User/app/: main.c app.c
    ./User/canfdspi/: drv_canfdspi_api.c
    ./User/spi/: drv_spi.c
    ./usb/: usbd_user_cdc_acm.c
  group New Group
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_bkp.c misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_exti.c stm32f10x_pwr.c
  group usb_config
    ./usb/: usb_config.c
  group usb hw driver
    ./usb/: usbd_STM32F10x_cl.c
  group usb library
    ./usb/: USB_CM3.lib
target STM32F105 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F105RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CanDemo_15 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_CL
  c include: ..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\CAN;..\Libraries\CMSIS\CM3\CoreSupport;.\User;.\User\app;.\User\canfdspi;.\User\spi;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\usb;.\usb\INC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 5.2.0
